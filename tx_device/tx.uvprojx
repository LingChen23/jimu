# Keil uVision project tx.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: nrf52832_xxaa_lfrc_rx +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: NRF_DFU_SETTINGS_VERSION=1 BLE_DFU_APP_SUPPORT HAL_NFC_ENGINEERING_BC_FTPAN_WORKAROUND BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0 ARM_MATH_CM4  __FPU_PRESENT=1
  c misc: --c99
  c include: .\lib_nRF\components\ble\ble_advertising;.\lib_nRF\components\ble\ble_dtm;.\lib_nRF\components\ble\ble_racp;.\lib_nRF\components\ble\ble_services\ble_ancs_c;.\lib_nRF\components\ble\ble_services\ble_ans_c;.\lib_nRF\components\ble\ble_services\ble_bas;.\lib_nRF\components\ble\ble_services\ble_bas_c;.\lib_nRF\components\ble\ble_services\ble_cscs;.\lib_nRF\components\ble\ble_services\ble_cts_c;.\lib_nRF\components\ble\ble_services\ble_dfu;.\lib_nRF\components\ble\ble_services\ble_dis;.\lib_nRF\components\ble\ble_services\ble_gls;.\lib_nRF\components\ble\ble_services\ble_hids;.\lib_nRF\components\ble\ble_services\ble_hrs;.\lib_nRF\components\ble\ble_services\ble_hrs_c;.\lib_nRF\components\ble\ble_services\ble_hts;.\lib_nRF\components\ble\ble_services\ble_ias;.\lib_nRF\components\ble\ble_services\ble_ias_c;.\lib_nRF\components\ble\ble_services\ble_lbs;.\lib_nRF\components\ble\ble_services\ble_lbs_c;.\lib_nRF\components\ble\ble_services\ble_lls;.\lib_nRF\components\ble\ble_services\ble_nus;.\lib_nRF\components\ble\ble_services\ble_nus_c;.\lib_nRF\components\ble\ble_services\ble_rscs;.\lib_nRF\components\ble\ble_services\ble_rscs_c;.\lib_nRF\components\ble\ble_services\ble_tps;.\lib_nRF\components\ble\common;.\lib_nRF\components\ble\nrf_ble_qwr;.\lib_nRF\components\ble\peer_manager;.\lib_nRF\components\boards;.\lib_nRF\components\device;.\lib_nRF\components\drivers_nrf\adc;.\lib_nRF\components\drivers_nrf\clock;.\lib_nRF\components\drivers_nrf\common;.\lib_nRF\components\drivers_nrf\comp;.\lib_nRF\components\drivers_nrf\delay;.\lib_nRF\components\drivers_nrf\gpiote;.\lib_nRF\components\drivers_nrf\hal;.\lib_nRF\components\drivers_nrf\i2s;.\lib_nRF\components\drivers_nrf\lpcomp;.\lib_nRF\components\drivers_nrf\pdm;.\lib_nRF\components\drivers_nrf\power;.\lib_nRF\components\drivers_nrf\ppi;.\lib_nRF\components\drivers_nrf\pwm;.\lib_nRF\components\drivers_nrf\qdec;.\lib_nRF\components\drivers_nrf\rng;.\lib_nRF\components\drivers_nrf\rtc;.\lib_nRF\components\drivers_nrf\saadc;.\lib_nRF\components\drivers_nrf\spi_master;.\lib_nRF\components\drivers_nrf\spi_slave;.\lib_nRF\components\drivers_nrf\swi;.\lib_nRF\components\drivers_nrf\timer;.\lib_nRF\components\drivers_nrf\twi_master;.\lib_nRF\components\drivers_nrf\twis_slave;.\lib_nRF\components\drivers_nrf\uart;.\lib_nRF\components\drivers_nrf\usbd;.\lib_nRF\components\drivers_nrf\wdt;.\lib_nRF\components\libraries\bsp;.\lib_nRF\components\libraries\button;.\lib_nRF\components\libraries\crc16;.\lib_nRF\components\libraries\crc32;.\lib_nRF\components\libraries\csense;.\lib_nRF\components\libraries\csense_drv;.\lib_nRF\components\libraries\experimental_section_vars;.\lib_nRF\components\libraries\fds;.\lib_nRF\components\libraries\fifo;.\lib_nRF\components\libraries\fstorage;.\lib_nRF\components\libraries\gpiote;.\lib_nRF\components\libraries\hardfault;.\lib_nRF\components\libraries\hci;.\lib_nRF\components\libraries\led_softblink;.\lib_nRF\components\libraries\log;.\lib_nRF\components\libraries\log\src;.\lib_nRF\components\libraries\low_power_pwm;.\lib_nRF\components\libraries\mem_manager;.\lib_nRF\components\libraries\pwm;.\lib_nRF\components\libraries\queue;.\lib_nRF\components\libraries\scheduler;.\lib_nRF\components\libraries\slip;.\lib_nRF\components\libraries\timer;.\lib_nRF\components\libraries\twi;.\lib_nRF\components\libraries\uart;.\lib_nRF\components\libraries\usbd;.\lib_nRF\components\libraries\usbd\class\audio;.\lib_nRF\components\libraries\usbd\class\cdc;.\lib_nRF\components\libraries\usbd\class\cdc\acm;.\lib_nRF\components\libraries\usbd\class\hid;.\lib_nRF\components\libraries\usbd\class\hid\generic;.\lib_nRF\components\libraries\usbd\class\hid\kbd;.\lib_nRF\components\libraries\usbd\class\hid\mouse;.\lib_nRF\components\libraries\usbd\class\msc;.\lib_nRF\components\libraries\usbd\config;.\lib_nRF\components\libraries\util;.\lib_nRF\components\softdevice\common\softdevice_handler;.\lib_nRF\components\softdevice\s132\headers;.\lib_nRF\components\softdevice\s132\headers\nrf52;.\lib_nRF\components\toolchain;.\include;.\lib_nRF\components\toolchain\cmsis\include;.\lib_nRF\components\boards;.\lib_nRF\components\libraries\bsp;.\lib_nRF\components\drivers_nrf\delay;.\lib_nRF\components\drivers_nrf\pwm;.\lib_sbc;.\lib_nRF\external\segger_rtt;.\lib_nRF\components\toolchain\cmsis\include;.\lib_nRF\components\toolchain\arm;.\lib_nRF\components\toolchain\cmsis\dsp\ARM;.\lib_nRF\components\drivers_nrf\wdt;.\lib_nRF\components\drivers_nrf\spi_master;.\lib_nRF\components\drivers_nrf\gpiote;.\nfc;.\lib_nRF\components\ble\ble_services\ble_dfu;.\lib_nRF\components\libraries\pwr_mgmt;.\lib_nRF\components\libraries\bootloader\dfu;.\lib_nRF\components\libraries\bootloader
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=3 BOARD_CUSTOM NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBSP_DEFINES_ONLY
  asm include: .\lib_nRF\components;.\lib_nRF\components\ble\ble_advertising;.\lib_nRF\components\ble\ble_dtm;.\lib_nRF\components\ble\ble_racp;.\lib_nRF\components\ble\ble_services\ble_ancs_c;.\lib_nRF\components\ble\ble_services\ble_ans_c;.\lib_nRF\components\ble\ble_services\ble_bas;.\lib_nRF\components\ble\ble_services\ble_bas_c;.\lib_nRF\components\ble\ble_services\ble_cscs;.\lib_nRF\components\ble\ble_services\ble_cts_c;.\lib_nRF\components\ble\ble_services\ble_dfu;.\lib_nRF\components\ble\ble_services\ble_dis;.\lib_nRF\components\ble\ble_services\ble_gls;.\lib_nRF\components\ble\ble_services\ble_hids;.\lib_nRF\components\ble\ble_services\ble_hrs;.\lib_nRF\components\ble\ble_services\ble_hrs_c;.\lib_nRF\components\ble\ble_services\ble_hts;.\lib_nRF\components\ble\ble_services\ble_ias;.\lib_nRF\components\ble\ble_services\ble_ias_c;.\lib_nRF\components\ble\ble_services\ble_lbs;.\lib_nRF\components\ble\ble_services\ble_lbs_c;.\lib_nRF\components\ble\ble_services\ble_lls;.\lib_nRF\components\ble\ble_services\ble_nus;.\lib_nRF\components\ble\ble_services\ble_nus_c;.\lib_nRF\components\ble\ble_services\ble_rscs;.\lib_nRF\components\ble\ble_services\ble_rscs_c;.\lib_nRF\components\ble\ble_services\ble_tps;.\lib_nRF\components\ble\common;.\lib_nRF\components\ble\nrf_ble_qwr;.\lib_nRF\components\ble\peer_manager;.\lib_nRF\components\boards;.\lib_nRF\components\device;.\lib_nRF\components\drivers_nrf\adc;.\lib_nRF\components\drivers_nrf\clock;.\lib_nRF\components\drivers_nrf\common;.\lib_nRF\components\drivers_nrf\comp;.\lib_nRF\components\drivers_nrf\delay;.\lib_nRF\components\drivers_nrf\gpiote;.\lib_nRF\components\drivers_nrf\hal;.\lib_nRF\components\drivers_nrf\i2s;.\lib_nRF\components\drivers_nrf\lpcomp;.\lib_nRF\components\drivers_nrf\pdm;.\lib_nRF\components\drivers_nrf\power;.\lib_nRF\components\drivers_nrf\ppi;.\lib_nRF\components\drivers_nrf\pwm;.\lib_nRF\components\drivers_nrf\qdec;.\lib_nRF\components\drivers_nrf\rng;.\lib_nRF\components\drivers_nrf\rtc;.\lib_nRF\components\drivers_nrf\saadc;.\lib_nRF\components\drivers_nrf\spi_master;.\lib_nRF\components\drivers_nrf\spi_slave;.\lib_nRF\components\drivers_nrf\swi;.\lib_nRF\components\drivers_nrf\timer;.\lib_nRF\components\drivers_nrf\twi_master;.\lib_nRF\components\drivers_nrf\twis_slave;.\lib_nRF\components\drivers_nrf\uart;.\lib_nRF\components\drivers_nrf\usbd;.\lib_nRF\components\drivers_nrf\wdt;.\lib_nRF\components\libraries\bsp;.\lib_nRF\components\libraries\button;.\lib_nRF\components\libraries\crc16;.\lib_nRF\components\libraries\crc32;.\lib_nRF\components\libraries\csense;.\lib_nRF\components\libraries\csense_drv;.\lib_nRF\components\libraries\experimental_section_vars;.\lib_nRF\components\libraries\fds;.\lib_nRF\components\libraries\fifo;.\lib_nRF\components\libraries\fstorage;.\lib_nRF\components\libraries\gpiote;.\lib_nRF\components\libraries\hardfault;.\lib_nRF\components\libraries\hci;.\lib_nRF\components\libraries\led_softblink;.\lib_nRF\components\libraries\log;.\lib_nRF\components\libraries\log\src;.\lib_nRF\components\libraries\low_power_pwm;.\lib_nRF\components\libraries\mem_manager;.\lib_nRF\components\libraries\pwm;.\lib_nRF\components\libraries\queue;.\lib_nRF\components\libraries\scheduler;.\lib_nRF\components\libraries\slip;.\lib_nRF\components\libraries\timer;.\lib_nRF\components\libraries\twi;.\lib_nRF\components\libraries\uart;.\lib_nRF\components\libraries\usbd;.\lib_nRF\components\libraries\usbd\class\audio;.\lib_nRF\components\libraries\usbd\class\cdc;.\lib_nRF\components\libraries\usbd\class\cdc\acm;.\lib_nRF\components\libraries\usbd\class\hid;.\lib_nRF\components\libraries\usbd\class\hid\generic;.\lib_nRF\components\libraries\usbd\class\hid\kbd;.\lib_nRF\components\libraries\usbd\class\hid\mouse;.\lib_nRF\components\libraries\usbd\class\msc;.\lib_nRF\components\libraries\usbd\config;.\lib_nRF\components\libraries\util;.\lib_nRF\components\softdevice\common\softdevice_handler;.\lib_nRF\components\softdevice\s132\headers;.\lib_nRF\components\softdevice\s132\headers\nrf52;.\lib_nRF\components\toolchain;..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20003000 size 0xd000
  group Application
    ./src/: main.c motion_packet.c motion_service.c sensor_icm_20689.c calc_common_func.c realtime_traj.c calc_traj.c
    ./include/: custom_board.h sdk_config.h sys_config.h tx_device_config.h
  group Board Definition
    ./lib_nRF/components/boards/: boards.c
  group Device
    ./lib_nRF/components/toolchain/: system_nrf52.c
    ./lib_nRF/components/toolchain/arm/: arm_startup_nrf52.s
  group Documentation
    ../../../: license.txt
  group nRF_BLE
    ./lib_nRF/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./lib_nRF/components/ble/ble_advertising/: ble_advertising.c
  group nRF_BLE_Services
    ./lib_nRF/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ./lib_nRF/components/drivers_nrf/clock/: nrf_drv_clock.c
    ./lib_nRF/components/drivers_nrf/common/: nrf_drv_common.c
    ./lib_nRF/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./lib_nRF/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./lib_nRF/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ./lib_nRF/components/drivers_nrf/power/: nrf_drv_power.c
    ./lib_nRF/components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ./lib_nRF/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ./lib_nRF/components/drivers_nrf/hal/: nrf_nvmc.c
    ./lib_nRF/components/libraries/crc32/: crc32.c
  group nRF_Libraries
    ./lib_nRF/components/libraries/button/: app_button.c
    ./lib_nRF/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ./lib_nRF/components/libraries/fifo/: app_fifo.c
    ./lib_nRF/components/libraries/timer/: app_timer.c
    ./lib_nRF/components/libraries/uart/: app_uart_fifo.c retarget.c
    ./lib_nRF/components/libraries/fstorage/: fstorage.c
    ./lib_nRF/components/libraries/hardfault/: hardfault_implementation.c
    ./lib_nRF/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
  group nRF_Log
    ./lib_nRF/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ./lib_nRF/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ./lib_nRF/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group lib_arm
    ./lib_arm/: arm_cortexM4lf_math.lib
  group nfc
    ./nfc/: hal_nfc_t2t.c nfc_ndef_msg.c nfc_ndef_record.c nfc_text_rec.c
target flash_s132_nrf52_3.0.0_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: ..\..\..\config\ble_app_uart_pca10028_s130;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
